options:
  parameters:
    category: '[DECT Hier Blocks]'
    generate_options: hb
    id: energy_tagger
    output_language: python
    title: DECT Energy Tagger
  states: {}

blocks:
- name: am_delay
  id: blocks_delay
  parameters:
    delay: '32'
    type: short
  states: {}
- name: am_demod
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: bbfilt
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.gaussian(2, 4, 1.2, 63)
    type: fff
  states: {}
- name: f2s
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: fm_delay
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: fm_demod
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: in
  id: pad_source
  parameters:
    type: complex
  states: {}
- name: ma
  id: blocks_moving_average_xx
  parameters:
    length: '64'
    max_iter: '4000'
    scale: 1.0/64
    type: float
  states: {}
- name: 'null'
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: out
  id: pad_sink
  parameters:
    type: float
  states: {}
- name: s2f
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: tagger
  id: blocks_burst_tagger
  parameters:
    false_key: EOB
    false_value: 'True'
    true_key: SOB
    true_value: 'True'
    type: float
  states: {}
- name: thresh
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold/4
  states: {}
- name: thresh_dbg
  id: pad_sink
  parameters:
    label: thresh
    optional: 'True'
    type: float
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    short_id: t
    type: eng_float
    value: '0.0002'
  states: {}

connections:
- [am_delay, '0', s2f, '0']
- [am_delay, '0', tagger, '1']
- [am_demod, '0', ma, '0']
- [bbfilt, '0', fm_delay, '0']
- [f2s, '0', am_delay, '0']
- [fm_delay, '0', tagger, '0']
- [fm_demod, '0', bbfilt, '0']
- [in, '0', am_demod, '0']
- [in, '0', fm_demod, '0']
- [ma, '0', thresh, '0']
- [s2f, '0', 'null', '0']
- [s2f, '0', thresh_dbg, '0']
- [tagger, '0', out, '0']
- [thresh, '0', f2s, '0']

metadata:
  file_format: 1
