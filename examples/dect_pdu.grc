options:
  parameters:
    author: J. Gilbert
    copyright: J. Gilbert
    description: DECT 6.0 PDU based demodulator
    generate_options: qt_gui
    id: dect_pdu
    output_language: python
    title: DECT PDU Demod
  states: {}

blocks:
- name: dect_obw
  id: variable
  parameters:
    value: 1.2*dect_symbol_rate
  states: {}
- name: dect_symbol_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '-1500000'
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Frequency (MHz)
    start: '1920.0'
    step: '0.05'
    stop: '1926.0'
    value: '1921.55'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '40'
  states: {}
- name: m
  id: variable
  parameters:
    value: 8*8
  states: {}
- name: n
  id: variable
  parameters:
    value: 8*40
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Threshold
    start: '0.00001'
    step: '0.00001'
    stop: '0.01'
    value: '0.0002'
  states: {}
- name: align
  id: pdu_utils_pdu_align
  parameters:
    comment: 0xAAAAE98A, 0x55551675
    offset: '-32'
    syncwords: 10101010101010101110100110001010, 01010101010101010001011001110101
    threshold: '0'
  states: {}
- name: chan_filt
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass_2(1, 1, 0.1, 0.025, 50)
    type: ccf
  states: {}
- name: clock_recovery
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: binary
    debug: 'False'
    win_type: pdu_utils.TUKEY_WIN
  states: {}
- name: clock_recovery_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: none
    debug: 'False'
    win_type: pdu_utils.TUKEY_WIN
  states: {}
- name: dect_deframer
  id: dect6_dect_deframer
  parameters: {}
  states: {}
- name: energy_tagger
  id: energy_tagger
  parameters:
    threshold: threshold
  states: {}
- name: file_src
  id: blocks_file_source
  parameters:
    file: /data/dect_01.sigmf-data
    repeat: 'True'
    type: short
  states: {state: disabled}
- name: head_tail
  id: pdu_utils_pdu_head_tail
  parameters:
    histsize: m
    length: n
    pdu_type: pdu_utils.INPUTTYPE_UNPACKED_BYTE
  states: {}
- name: i2c
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: pow(2,15)
    vector_input: 'False'
  states: {state: disabled}
- name: input_fir
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fc
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass_2(1, samp_rate, dect_obw/2, 250e3, 40)
    type: ccf
  states: {state: disabled}
- name: input_resamp
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 4*dect_symbol_rate / (samp_rate)
    type: ccf
  states: {}
- name: msg_dbg_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: << VERY VERBOSE!
  states: {}
- name: pack
  id: pdu_utils_pack_unpack
  parameters:
    bit_order: pdu_utils.BIT_ORDER_MSB_FIRST
    mode: pdu_utils.MODE_PACK_BYTE
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    invert: 'False'
    k: pmt.intern("part")
    v: pmt.intern("RFP")
  states: {state: bypassed}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,1
    type: complex
    update_time: '0.01'
  states: {}
- name: raster
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    gui_hint: 5,1,1,1
    ncols: n
    nrows: m
    samp_rate: samp_rate
    type: msg_byte
  states: {}
- name: tags2pdu
  id: pdu_tags_to_pdu_x
  parameters:
    end_tag: EOB
    max_pdu_size: '4096'
    rate: dect_symbol_rate*4
    start_tag: SOB
    type: f
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    samples_per_second: 8e6/100
    type: complex
  states: {state: disabled}
- name: time_sink1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,1
    nconnections: '2'
    size: '4096'
    srate: samp_rate
    tr_chan: '1'
    tr_delay: '.0001'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"SOB"'
    type: float
  states: {}
- name: ts
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,1
    name: '"Soft Symbols"'
    srate: dect_symbol_rate
    stemplot: 'True'
    type: msg_float
  states: {}
- name: unpack
  id: pdu_utils_pack_unpack
  parameters:
    bit_order: pdu_utils.BIT_ORDER_MSB_FIRST
    mode: pdu_utils.MODE_UNPACK_BYTE
  states: {}
- name: usrp
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq*1e6
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: v_in
  id: virtual_source
  parameters:
    stream_id: in
  states: {}
- name: v_pdus
  id: virtual_source
  parameters:
    stream_id: pdus
  states: {}
- name: vs_in
  id: virtual_sink
  parameters:
    stream_id: in
  states: {}
- name: vs_pdus
  id: virtual_sink
  parameters:
    stream_id: pdus
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,0,3,1
    type: complex
    update_time: '.002'
  states: {}

connections:
- [align, pdu_out, vs_pdus, '0']
- [chan_filt, '0', input_resamp, '0']
- [clock_recovery, pdu_out, align, pdu_in]
- [clock_recovery_0, pdu_out, ts, in]
- [dect_deframer, pdu, msg_dbg_0, print]
- [dect_deframer, pdu, unpack, pdu_in]
- [energy_tagger, '0', tags2pdu, '0']
- [energy_tagger, '0', time_sink1, '1']
- [energy_tagger, '1', time_sink1, '0']
- [file_src, '0', i2c, '0']
- [head_tail, head, raster, in]
- [i2c, '0', throttle, '0']
- [input_fir, '0', input_resamp, '0']
- [input_resamp, '0', vs_in, '0']
- [input_resamp, '0', waterfall, '0']
- [pack, pdu_out, dect_deframer, pdu]
- [pdu_pdu_filter_0, pdus, head_tail, pdu_in]
- [tags2pdu, pdus, clock_recovery, pdu_in]
- [tags2pdu, pdus, clock_recovery_0, pdu_in]
- [throttle, '0', input_fir, '0']
- [unpack, pdu_out, pdu_pdu_filter_0, pdus]
- [usrp, '0', chan_filt, '0']
- [usrp, '0', qtgui_freq_sink_x_0, '0']
- [v_in, '0', energy_tagger, '0']
- [v_pdus, '0', pack, pdu_in]

metadata:
  file_format: 1
